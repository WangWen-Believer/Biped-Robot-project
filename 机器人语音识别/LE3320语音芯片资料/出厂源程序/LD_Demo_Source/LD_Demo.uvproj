# Keil uVision project LD_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: LD_Demo +hex
  c flags: Optimize=8
  group Source Group 1
    ./: main.c LDChip.c Reg_RW.c
