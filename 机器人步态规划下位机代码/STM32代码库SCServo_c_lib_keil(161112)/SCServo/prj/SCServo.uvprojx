# Keil uVision project SCServo.uvprojx, settings and files
target SCServo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SCServo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\STM32F10x\StdPeriph_Driver\inc;..\SCSLib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x
    ../STM32F10x/StdPeriph_Driver/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ../STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group examples
    ../examples/: Broadcast.c ProgramEprom.c ReadPos.c ReadTemper.c ReadVol.c RegWritePos.c SyncWritePos.c WritePos.c WriteSpe.c
  group SCSLib
    ../SCSLib/: SCSProtocol.c SCServo.c uart.c wiring.c main.c
software components: CMSIS:CORE 5.0.1
