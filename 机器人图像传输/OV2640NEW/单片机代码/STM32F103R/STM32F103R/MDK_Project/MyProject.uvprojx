# Keil uVision project MyProject.uvprojx, settings and files
target Project_Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyProject +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\MyBSP\LCD_Driver;..\MyBSP\Nand_Flash;..\MyBSP\NOR_Flash;..\MyBSP\SRAM;..\MyBSP\Utilities;..\Usrer\STM32_cfg;..\Usrer\STM32_it;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\MyBSP\SD_Driver;..\Usrer\fatfs;..\MyBSP;..\OnChip_Drivers;..\MyBSP\USB\Mass_Storage\inc;..\MyBSP\USB\hw_config;..\MyBSP\OV7670_Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Usrer/main/: main.c
    ../Usrer/STM32_it/: stm32f10x_it.c
  group MyBSP
    ../MyBSP/LCD_Driver/: stm3210e_eval_lcd.c
    ../MyBSP/Utilities/: stm3210e_eval.c stm32_eval.c
    ../MyBSP/SD_Driver/: sd_driver.c
  group MyBsp_USART
    ../MyBSP/USART/: USART.c
  group MyBsp_LedKey
    ../MyBSP/LED_Key/: LED_Key.c
  group MyBsp_Delay
    ../MyBSP/Delay/: Delay.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_pwr.c
  group FatFs
    ../Usrer/fatfs/: diskio.c FATFS_008.c
    ../Usrer/fatfs/option/: ccsbcs.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RVMDK
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group OnChip_Drivers
    ../OnChip_Drivers/SPI/: SPI.c
    ../OnChip_Drivers/NVIC_EXIT/: Nvic_Exit.c
  group MyBsp_Wifi
    ../MyBSP/Wifi/: Wifi_Spi.c if_gspi.c
  group LCD_Driver
    ../MyBSP/LCD_Driver/: LCD_Driver.c LCD_GUI.c
  group OV7670_Driver
    ../MyBSP/OV7670_Driver/: FIFO.c ov7670.c SCCB.c
  group OV2640
    ../MyBSP/OV2640/: dcmi_ov2640.c
software components: CMSIS:CORE 5.0.1
